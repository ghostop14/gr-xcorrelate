options:
  parameters:
    author: ghostop14
    generate_options: qt_gui
    id: freq_domain_xcorr
    output_language: python
    title: Frequency Domain Cross-Correlation
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 95.7e6
  states: {}
- name: chans
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: delay_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: delay_1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: delay_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,4,1,1
    label: Correcting Delay - Block
    type: int
    value: delay_0
  states: {}
- name: delay_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,4,1,1
    label: Correcting Delay - XCorrelate
    type: int
    value: delay_1
  states: {}
- name: filter_cutoff
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: fm_sample
  id: variable
  parameters:
    value: int(samp_rate/stage1_decimation)
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '2'
    stop: '60'
    value: '32'
  states: {}
- name: lag
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Induced Lag
    orient: Qt.Horizontal
    rangeType: int
    start: '-20'
    step: '1'
    stop: '20'
    value: '10'
  states: {}
- name: lock_output
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 1,1,1,1
    label: Lock Correlator Lag
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: stage1_decimation
  id: variable
  parameters:
    value: int(samp_rate/600e3)
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.2'
    stop: '5.0'
    value: '1.0'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    comment: Quadrature rate is the input rate
    quad_rate: int(samp_rate/stage1_decimation)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters:
    vlen: chans
  states: {}
- name: blocks_deinterleave_1
  id: blocks_deinterleave
  parameters:
    blocksize: int(chans/2)
    comment: FFTshift
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: lag
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: delay_0
    type: complex
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    blocksize: int(chans/2)
    type: float
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: stage1_decimation
    type: complex
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: '200'
    type: float
    vlen: chans
  states: {}
- name: blocks_keep_one_in_n_1_0
  id: blocks_keep_one_in_n
  parameters:
    n: '200'
    type: float
    vlen: chans
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: chans
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: chans
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: chans
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: chans
    type: float
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: chans
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: chans
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[1.0,]*chans'
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: chans
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[1.0,]*chans'
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: chans
    forward: 'False'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: lfast_low_pass_filter_0_0
  id: lfast_low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: filter_cutoff
    decim: '1'
    gain: '1'
    nthreads: '1'
    samp_rate: samp_rate
    type: ccc
    width: filter_cutoff*.1
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 3,0,2,4
    label1: Reference
    label2: Signal 1
    label3: Correlated
    nconnections: '3'
    size: '64'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    gui_hint: 2,0,1,4
    label1: Blockwise
    label2: XCorrelate
    nconnections: '2'
    showports: 'True'
    vlen: chans
    x_start: '-chans/2'
    x_step: '1.0'
    ymax: '10.0'
    ymin: '-1.0'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(fm_sample/10000)
    interp: int(audio_rate/1e3)
    taps: ''
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    clock_rate: '0.0'
    dc_offs_enb0: 'True'
    dev_args: '"num_recv_frames=128"'
    gain0: gain
    iq_imbal_enb0: 'True'
    norm_gain0: 'False'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: xcorrelate_ExtractDelay_0
  id: xcorrelate_ExtractDelay
  parameters:
    index_to_extract: '0'
    lock: 'False'
    minCorrScore: '0.6'
    target: delay_1
  states: {state: disabled}
- name: xcorrelate_VectorMaxIndexToVar_0
  id: xcorrelate_VectorMaxIndexToVar
  parameters:
    lock: lock_output
    minCorrScore: '5'
    target: delay_0
    vec_len: chans
  states: {}
- name: xcorrelate_VectorMaxIndexToVar_0_0
  id: xcorrelate_VectorMaxIndexToVar
  parameters:
    lock: lock_output
    minCorrScore: '5'
    target: delay_1
    vec_len: chans
  states: {}
- name: xcorrelate_xcorrelate_fft_vcf_0
  id: xcorrelate_xcorrelate_fft_vcf
  parameters:
    vec_len: chans
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_mag_0_0_0, '0']
- [blocks_add_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_complex_to_mag_1, '0', blocks_vector_to_stream_1, '0']
- [blocks_deinterleave_1, '0', blocks_interleave_0, '1']
- [blocks_deinterleave_1, '1', blocks_interleave_0, '0']
- [blocks_delay_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_delay_0, '0', blocks_delay_1, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_delay_1, '0', blocks_add_xx_0, '1']
- [blocks_interleave_0, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_keep_one_in_n_0, '0', analog_wfm_rcv_0, '0']
- [blocks_keep_one_in_n_1, '0', xcorrelate_VectorMaxIndexToVar_0, '0']
- [blocks_keep_one_in_n_1_0, '0', xcorrelate_VectorMaxIndexToVar_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', fft_vxx_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', blocks_keep_one_in_n_1, '0']
- [blocks_stream_to_vector_0_1, '0', qtgui_vector_sink_f_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_deinterleave_1, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [fft_vxx_0, '0', xcorrelate_xcorrelate_fft_vcf_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [fft_vxx_0_0, '0', xcorrelate_xcorrelate_fft_vcf_0, '1']
- [fft_vxx_0_1, '0', blocks_complex_to_mag_1, '0']
- [lfast_low_pass_filter_0_0, '0', blocks_add_xx_0, '0']
- [lfast_low_pass_filter_0_0, '0', blocks_complex_to_mag_0, '0']
- [lfast_low_pass_filter_0_0, '0', blocks_delay_0, '0']
- [lfast_low_pass_filter_0_0, '0', blocks_stream_to_vector_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', lfast_low_pass_filter_0_0, '0']
- [xcorrelate_xcorrelate_fft_vcf_0, '0', blocks_keep_one_in_n_1_0, '0']
- [xcorrelate_xcorrelate_fft_vcf_0, '0', qtgui_vector_sink_f_0, '1']
- [xcorrelate_xcorrelate_fft_vcf_0, corrmsg, xcorrelate_ExtractDelay_0, corr]

metadata:
  file_format: 1
