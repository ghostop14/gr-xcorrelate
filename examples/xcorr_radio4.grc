options:
  parameters:
    author: ghostop14
    generate_options: qt_gui
    id: xcorr_fm_radio4
    output_language: python
    title: Cross Correlate - 4 Inputs
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency
    type: real
    value: 95.7e6
  states: {}
- name: corr_frame_decim
  id: variable
  parameters:
    value: '100'
  states: {}
- name: corr_frame_size
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: delay_0
  id: variable
  parameters:
    comment: |-
      Must have a variable on the flowgraph
      for the "variable" field on the "Extract Delay" block.
    value: '0'
  states: {}
- name: delay_1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: delay_2
  id: variable
  parameters:
    value: '0'
  states: {}
- name: delay_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 3,0,1,1
    label: Correcting Delay [0,1]
    type: int
    value: delay_0
  states: {}
- name: delay_label1
  id: variable_qtgui_label
  parameters:
    gui_hint: 3,1,1,1
    label: Correcting Delay [0,2]
    type: int
    value: delay_1
  states: {}
- name: delay_label2
  id: variable_qtgui_label
  parameters:
    gui_hint: 3,2,1,1
    label: Correcting Delay [0,3]
    type: int
    value: delay_2
  states: {}
- name: filter_cutoff
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: fm_sample
  id: variable
  parameters:
    value: int(samp_rate/stage1_decimation)
  states: {}
- name: fm_width
  id: variable
  parameters:
    value: '64000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '2'
    stop: '60'
    value: '32'
  states: {}
- name: lock_output
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 3,3,1,1
    label: Lock Correlator Lag
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: max_search
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: min_corr_score
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: stage1_decimation
  id: variable
  parameters:
    value: int(samp_rate/600e3)
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.2'
    stop: '5.0'
    value: '1.0'
  states: {}
- name: working_samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    comment: Quadrature rate is the input rate
    quad_rate: int(samp_rate/stage1_decimation)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_0
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_1
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_2
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: stage1_decimation
    type: complex
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: '1024'
    vlen_out: '1'
  states: {}
- name: blocks_max_xx_0_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: '1024'
    vlen_out: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: correctiq_correctiq_auto_0
  id: correctiq_correctiq_auto
  parameters:
    freq: center_freq
    gain: gain
    samp_rate: samp_rate
    syncWindow: '2'
  states: {}
- name: correctiq_correctiq_auto_0_0
  id: correctiq_correctiq_auto
  parameters:
    freq: center_freq
    gain: gain
    samp_rate: samp_rate
    syncWindow: '2'
  states: {}
- name: correctiq_correctiq_auto_0_0_0
  id: correctiq_correctiq_auto
  parameters:
    freq: center_freq
    gain: gain
    samp_rate: samp_rate
    syncWindow: '2'
  states: {}
- name: correctiq_correctiq_auto_0_0_0_0
  id: correctiq_correctiq_auto
  parameters:
    freq: center_freq
    gain: gain
    samp_rate: samp_rate
    syncWindow: '2'
  states: {}
- name: lfast_low_pass_filter_0_0
  id: lfast_low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: filter_cutoff
    decim: '1'
    gain: '1'
    nthreads: '1'
    samp_rate: samp_rate
    type: ccc
    width: filter_cutoff*.1
    win: window.WIN_HAMMING
  states: {}
- name: lfast_low_pass_filter_0_0_0
  id: lfast_low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: filter_cutoff
    decim: '1'
    gain: '1'
    nthreads: '1'
    samp_rate: samp_rate
    type: ccc
    width: filter_cutoff*.1
    win: window.WIN_HAMMING
  states: {}
- name: lfast_low_pass_filter_0_0_0_0
  id: lfast_low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: filter_cutoff
    decim: '1'
    gain: '1'
    nthreads: '1'
    samp_rate: samp_rate
    type: ccc
    width: filter_cutoff*.1
    win: window.WIN_HAMMING
  states: {}
- name: lfast_low_pass_filter_0_0_0_0_0
  id: lfast_low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: filter_cutoff
    decim: '1'
    gain: '1'
    nthreads: '1'
    samp_rate: samp_rate
    type: ccc
    width: filter_cutoff*.1
    win: .WIN_HAMMING
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: '1024'
    frame_rate: '30'
    ref_scale: '2'
    sample_rate: samp_rate
    type: complex
  states: {}
- name: logpwrfft_x_0_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: '1024'
    frame_rate: '30'
    ref_scale: '2'
    sample_rate: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 1,0,2,2
    label1: Reference
    label2: Signal1
    label3: Signal2
    label4: Signal3
    label5: Correlated
    name: '"Uncorrelated"'
    nconnections: '5'
    type: complex
    ymax: '-10'
    ymin: '-80'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 1,2,2,2
    label1: Reference
    name: '"Correlated"'
    type: complex
    ymax: '-10'
    ymin: '-80'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    color2: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 6,0,1,3
    label1: Ref Signal
    label2: Correlated
    max: '-10'
    min: '-60'
    name: Max Power
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 7,0,1,3
    label1: '""'
    max: '10'
    min: '-10'
    name: '"Improvement Over Reference"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 5,0,1,4
    label1: Reference
    label2: Signal 1
    label3: Signal 2
    label4: Signal 3
    label5: Correlated
    nconnections: '5'
    size: '64'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 4,0,1,4
    int_max: '-10'
    int_min: '-60'
    type: complex
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(fm_sample/10000)
    interp: int(audio_rate/1e3)
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: gain
    freq0: center_freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rtlsdr_source_0_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=1"'
    bb_gain0: gain
    freq0: center_freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rtlsdr_source_0_0_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=2"'
    bb_gain0: gain
    freq0: center_freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rtlsdr_source_0_0_0_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=3"'
    bb_gain0: gain
    freq0: center_freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: xcorrelate_ExtractDelay_0
  id: xcorrelate_ExtractDelay
  parameters:
    index_to_extract: '0'
    lock: lock_output
    minCorrScore: min_corr_score
    target: delay_0
  states: {}
- name: xcorrelate_ExtractDelay_0_0
  id: xcorrelate_ExtractDelay
  parameters:
    index_to_extract: '1'
    lock: lock_output
    minCorrScore: min_corr_score
    target: delay_1
  states: {}
- name: xcorrelate_ExtractDelay_0_0_0
  id: xcorrelate_ExtractDelay
  parameters:
    index_to_extract: '2'
    lock: lock_output
    minCorrScore: min_corr_score
    target: delay_2
  states: {}
- name: xcorrelate_xcorrelate_0
  id: xcorrelate_xcorrelate
  parameters:
    affinity: '0'
    async: 'True'
    decim_frames: corr_frame_decim
    max_search_offset: max_search
    num_inputs: '4'
    signal_length: corr_frame_size
    type: float
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_mag_0_0_0_1, '0']
- [blocks_add_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_add_xx_0, '0', logpwrfft_x_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '4']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', xcorrelate_xcorrelate_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_0_0, '0', xcorrelate_xcorrelate_0, '1']
- [blocks_complex_to_mag_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_complex_to_mag_0_0_0, '0', xcorrelate_xcorrelate_0, '2']
- [blocks_complex_to_mag_0_0_0_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_complex_to_mag_0_0_0_0, '0', xcorrelate_xcorrelate_0, '3']
- [blocks_complex_to_mag_0_0_0_1, '0', qtgui_time_sink_x_0, '4']
- [blocks_delay_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_delay_0_0_0_0_0, '0', blocks_add_xx_0, '3']
- [blocks_keep_one_in_n_0, '0', analog_wfm_rcv_0, '0']
- [blocks_max_xx_0, '0', blocks_sub_xx_0, '0']
- [blocks_max_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_max_xx_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_max_xx_0_0, '0', qtgui_number_sink_0, '1']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [correctiq_correctiq_auto_0, '0', lfast_low_pass_filter_0_0_0_0_0, '0']
- [correctiq_correctiq_auto_0_0, '0', lfast_low_pass_filter_0_0_0_0, '0']
- [correctiq_correctiq_auto_0_0_0, '0', lfast_low_pass_filter_0_0_0, '0']
- [correctiq_correctiq_auto_0_0_0_0, '0', lfast_low_pass_filter_0_0, '0']
- [lfast_low_pass_filter_0_0, '0', blocks_add_xx_0, '0']
- [lfast_low_pass_filter_0_0, '0', blocks_complex_to_mag_0, '0']
- [lfast_low_pass_filter_0_0, '0', logpwrfft_x_0, '0']
- [lfast_low_pass_filter_0_0, '0', qtgui_freq_sink_x_0, '0']
- [lfast_low_pass_filter_0_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [lfast_low_pass_filter_0_0_0, '0', blocks_delay_0_0_0, '0']
- [lfast_low_pass_filter_0_0_0, '0', qtgui_freq_sink_x_0, '1']
- [lfast_low_pass_filter_0_0_0_0, '0', blocks_complex_to_mag_0_0_0, '0']
- [lfast_low_pass_filter_0_0_0_0, '0', blocks_delay_0_0_0_0, '0']
- [lfast_low_pass_filter_0_0_0_0, '0', qtgui_freq_sink_x_0, '2']
- [lfast_low_pass_filter_0_0_0_0_0, '0', blocks_complex_to_mag_0_0_0_0, '0']
- [lfast_low_pass_filter_0_0_0_0_0, '0', blocks_delay_0_0_0_0_0, '0']
- [lfast_low_pass_filter_0_0_0_0_0, '0', qtgui_freq_sink_x_0, '3']
- [logpwrfft_x_0, '0', blocks_max_xx_0, '0']
- [logpwrfft_x_0_0, '0', blocks_max_xx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', correctiq_correctiq_auto_0_0_0_0, '0']
- [rtlsdr_source_0_0, '0', correctiq_correctiq_auto_0_0_0, '0']
- [rtlsdr_source_0_0_0, '0', correctiq_correctiq_auto_0_0, '0']
- [rtlsdr_source_0_0_0_0, '0', correctiq_correctiq_auto_0, '0']
- [xcorrelate_xcorrelate_0, corr, xcorrelate_ExtractDelay_0, corr]
- [xcorrelate_xcorrelate_0, corr, xcorrelate_ExtractDelay_0_0, corr]
- [xcorrelate_xcorrelate_0, corr, xcorrelate_ExtractDelay_0_0_0, corr]

metadata:
  file_format: 1
