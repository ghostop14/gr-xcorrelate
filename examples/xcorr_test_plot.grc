options:
  parameters:
    author: ghostop14
    generate_options: qt_gui
    id: xcorr_test_plot
    output_language: python
    title: Cross Correlation Test
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 95.7e6
  states: {}
- name: corr_frame_decim
  id: variable
  parameters:
    value: '6'
  states: {}
- name: corr_frame_size
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: delay_0
  id: variable
  parameters:
    comment: |-
      Must have a variable on the flowgraph
      for the "variable" field on the "Extract Delay" block.
    value: '0'
  states: {}
- name: delay_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,4,1,1
    label: Correcting Delay
    type: int
    value: delay_0
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '2'
    stop: '60'
    value: '32'
  states: {}
- name: lag
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    label: lag
    orient: Qt.Horizontal
    rangeType: int
    start: '-20'
    step: '1'
    stop: '20'
    value: '10'
  states: {}
- name: max_search
  id: variable
  parameters:
    value: '512'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: lag
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_0
    type: complex
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: float
    vlen: 2*corr_frame_size
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: '1024'
    vlen_out: '1'
  states: {}
- name: blocks_max_xx_0_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: '1024'
    vlen_out: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: '1024'
    frame_rate: '30'
    ref_scale: '2'
    sample_rate: samp_rate
    type: complex
  states: {}
- name: logpwrfft_x_0_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: '1024'
    frame_rate: '30'
    ref_scale: '2'
    sample_rate: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 1,0,2,2
    label1: Reference
    label2: Delayed
    label3: Correlated
    nconnections: '3'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-100'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    color2: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 6,0,1,1
    label1: Ref Signal
    label2: Correlated
    max: '-10'
    min: '-100'
    name: Max Power
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 7,0,1,1
    max: '10'
    min: '-10'
    name: '"Improvement"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 4,0,2,4
    label1: Reference
    label2: Signal 1
    label3: Correlated
    nconnections: '3'
    size: '64'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: 1,2,2,2
    name: '"Correlation Vs. Sample Lag"'
    vlen: corr_frame_size*2
    x_axis_label: '"Corrective Lag"'
    x_start: '-corr_frame_size'
    x_step: '1.0'
    x_units: '"Samples"'
    y_axis_label: '"Normalized Correlation"'
    ymax: '1.0'
    ymin: '0.5'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    clock_rate: '0.0'
    dc_offs_enb0: 'True'
    dev_args: '"num_recv_frames=128"'
    gain0: gain
    iq_imbal_enb0: 'True'
    norm_gain0: 'False'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: xcorrelate_ExtractDelay_0
  id: xcorrelate_ExtractDelay
  parameters:
    index_to_extract: '0'
    lock: 'False'
    minCorrScore: '0.6'
    target: delay_0
  states: {}
- name: xcorrelate_xcorrelate_xtream_0
  id: xcorrelate_xcorrelate_xtream
  parameters:
    decim_frames: '6'
    max_search_offset: '256'
    num_inputs: '2'
    signal_length: '8192'
    type: float
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_complex_to_mag_0_0_0, '0']
- [blocks_add_xx_0, '0', logpwrfft_x_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '2']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', xcorrelate_xcorrelate_xtream_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_0_0, '0', xcorrelate_xcorrelate_xtream_0, '1']
- [blocks_complex_to_mag_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_delay_0, '0', blocks_delay_0_0_0, '0']
- [blocks_delay_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_delay_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_keep_one_in_n_1, '0', qtgui_vector_sink_f_0, '0']
- [blocks_max_xx_0, '0', blocks_sub_xx_0, '0']
- [blocks_max_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_max_xx_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_max_xx_0_0, '0', qtgui_number_sink_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [logpwrfft_x_0, '0', blocks_max_xx_0, '0']
- [logpwrfft_x_0_0, '0', blocks_max_xx_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_add_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_0, '0']
- [uhd_usrp_source_0, '0', blocks_delay_0, '0']
- [uhd_usrp_source_0, '0', logpwrfft_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [xcorrelate_xcorrelate_xtream_0, '0', blocks_keep_one_in_n_1, '0']
- [xcorrelate_xcorrelate_xtream_0, corr, xcorrelate_ExtractDelay_0, corr]

metadata:
  file_format: 1
