options:
  parameters:
    author: ghostop14
    generate_options: qt_gui
    id: fm_radio
    output_language: python
    title: Radio single test case
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency
    type: real
    value: 95.7e6
  states: {}
- name: filter_cutoff
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: fm_sample
  id: variable
  parameters:
    value: int(samp_rate/stage1_decimation)
  states: {}
- name: fm_width
  id: variable
  parameters:
    value: '64000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '2'
    stop: '60'
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: stage1_decimation
  id: variable
  parameters:
    value: int(samp_rate/600e3)
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.2'
    stop: '5.0'
    value: '1.0'
  states: {}
- name: working_samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    comment: Quadrature rate is the input rate
    quad_rate: int(samp_rate/stage1_decimation)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: lfast_low_pass_filter_0
  id: lfast_low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: filter_cutoff
    decim: stage1_decimation
    gain: '1'
    nthreads: '1'
    samp_rate: samp_rate
    type: ccc
    width: filter_cutoff*.2
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 1,0,2,4
    label1: Reference
    name: Single Input
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-80'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 4,0,1,4
    int_max: '-10'
    int_min: '-60'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(fm_sample/10000)
    interp: int(audio_rate/1e3)
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: gain
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [lfast_low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', lfast_low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
